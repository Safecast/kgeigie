File: PCB board/noname.kicad_pcb (KiCad board)
At the start: 2 copper layers, 58.2 x 27.9 mm, 14 parts

Commit message: Cleaned up
Other:
- net class Default removed
